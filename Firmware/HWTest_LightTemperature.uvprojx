# Keil uVision project HWTest_LightTemperature.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L052C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HWTest_LightTemperature
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./src/: main_HWTest_LightTemperature.cpp Ports.cpp Ports.h Clock.cpp Clock.h Heartbeat.cpp Heartbeat.h UI.cpp UI.h LightTemperature.cpp LightTemperature.h
software components: CMSIS:CORE 5.0.0, Device:Startup 1.6.0
