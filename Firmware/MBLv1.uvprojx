# Keil uVision project MBLv1.uvprojx, settings and files
target MBLv1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L052C8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MBLv1
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group main
    ./src/: main.cpp Clock.cpp Clock.h Ports.cpp Ports.h UI.cpp UI.h
software components: CMSIS:CORE 5.0.0, USB:CORE 6.5.0, USB:Device:HID 6.5.0, Device:Startup 1.4.0
